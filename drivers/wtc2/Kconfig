## drivers/wtc2/Kconfig
```kconfig
config wtc2_MOD
	tristate "wtc2 Kernel Module"
	default m
	depends on MODULES
	help
	  wtc2 Kernel Module
```
